RRECOMMENDS_${PN}_remove = "catfish"
RRECOMMENDS_${PN}_remove = "xfce4-sensors-plugin"
RRECOMMENDS_${PN}_remove = "xfce4-whiskermenu-plugin"
