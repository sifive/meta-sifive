FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

PV = "0.9+git${SRCPV}"

SRCREV = "bd355213bfbb209c047e8cc0df56936f6705477f"

EXTRA_OEMAKE += "INSTALL_LIB_PATH=lib"
