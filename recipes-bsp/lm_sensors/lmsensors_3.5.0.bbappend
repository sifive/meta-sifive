RDEPENDS_${PN}-pwmconfig_append = " bash"
