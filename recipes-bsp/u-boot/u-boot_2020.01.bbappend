FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append_freedom-u540 = " \
        file://mmc-boot.txt \
        "
