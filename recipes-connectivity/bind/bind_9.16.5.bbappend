inherit update-alternatives
