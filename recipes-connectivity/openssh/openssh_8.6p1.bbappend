SYSTEMD_AUTO_ENABLE_${PN}-sshd = "disable"
SYSTEMD_AUTO_ENABLE_${PN} = "disable"
