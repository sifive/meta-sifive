SYSTEMD_AUTO_ENABLE_${PN}-client = "disable"
SYSTEMD_AUTO_ENABLE_${PN} = "disable"
