LDFLAGS_append = " -latomic"
