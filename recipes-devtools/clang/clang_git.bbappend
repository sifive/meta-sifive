LDFLAGS_remove_class-nativesdk = "-fuse-ld=lld"
