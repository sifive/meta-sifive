PACKAGECONFIG[pmem] = "--enable-libpmem,--disable-libpmem,libpmem"
