require qemu-sifive.inc

PACKAGECONFIG[pmem] = "--enable-libpmem,--disable-libpmem,libpmem"
