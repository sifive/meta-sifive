PACKAGECONFIG[seccomp] = "--enable-libseccomp,--disable-seccomp,libseccomp"
