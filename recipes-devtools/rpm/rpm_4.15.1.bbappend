EXTRA_OECONF_append_class-native = " --disable-openmp"
EXTRA_OECONF_append_class-nativesdk = " --disable-openmp"
