RDEPENDS_${PN}_remove = "dhcpcd"
